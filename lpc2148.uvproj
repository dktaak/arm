# Keil uVision project lpc2148.uvproj, settings and files
target LPC2148 (ARM-ADS)
  device: LPC2148 NXP
  cpu: IRAM(0x40000000-0x40007FFF) IROM(0-0x7FFFF) CLOCK(12000000) CPUTYPE(ARM7TDMI)
  output: arm_adc +hex
  c flags: Optim=1
  memory RVCT4: ROM 0x0 size 0x80000
  memory RVCT9: RAM 0x40000000 size 0x8000
  group drivers
    ./: timer0_driver.c gpio_driver.c lcd_driver.c keyboard_driver.c uart_driver.c adc0_driver.c
  group apllication
    ./: Startup.s main_timer0.c main_gpio.c lcd_main.c keyboard_main.c uart_main.c adc0_main.c
